# Keil uVision project 简易水情检测装置.uvproj, settings and files
target 简易水情检测装置 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 简易水情检测装置 +hex
  c flags: Optimize=8 SizeSpeed=1
  group software
    ../: Readme.txt
  group ABS_TASK
    ../SOFTWARE/: absTask.c
  group TASK
    ../SOFTWARE/TASK/setup/: setup.c
    ../SOFTWARE/TASK/mode/: mode.c
  group COMMON_SOFTWARE
    ../SOFTWARE/TASK/COMMON_SOFTWARE/ALGORITHM/DIGITAL_FILTER/FILTER/: FILTER.C
    ../SOFTWARE/TASK/COMMON_SOFTWARE/ALGORITHM/PID/: PID.c
    ../SOFTWARE/TASK/COMMON_SOFTWARE/DATA_SCOPE/: DataScope_DP.c
    ../SOFTWARE/: Readme.txt
  group DEVICES
    ../HARDWARE/BUTTON/: BUTTON.C
    ../HARDWARE/DISPLAY/LCD5110/: LCD5510_V2.C
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/MOTOR/DC_MOTOR/: MOTOR.C
    ../HARDWARE/MOTOR/SERVO/: SERVO.C
    ../HARDWARE/MOTOR/STEP_MOTOR/: STEP_MOTOR.C
    ../HARDWARE/SENSOR/ANGLE/: ANGLE.C
    ../HARDWARE/: Readme.txt.txt
    ../HARDWARE/SENSOR/phSensor/: phSensor.c
    ../HARDWARE/SENSOR/liquidometer/: liquidometer.c
    ../HARDWARE/SPEAKER/: speaker.c
  group COMMON_HARDWARE
    ../HARDWARE/COMMON_HARDWARE/fixedPulser/: fixedPulser.c
    ../HARDWARE/COMMON_HARDWARE/L298N/: MT_1_L298N.c
    ../HARDWARE/COMMON_HARDWARE/MPU9250/: MPU9250_SBUF.C
    ../HARDWARE/COMMON_HARDWARE/RELAY/: RELAY.C
    ../HARDWARE/COMMON_HARDWARE/TM1638/: TM1638.c
    ../HARDWARE/COMMON_HARDWARE/: Readme.txt
    ../HARDWARE/COMMON_HARDWARE/ADS1115/: ADS1115.C
    ../HARDWARE/COMMON_HARDWARE/74H/: 74HC595.C 74LS165.C
    ../HARDWARE/COMMON_HARDWARE/hc_sr04/: hc_sr04.c
    ../HARDWARE/WIRELESS/NRF24L01/: NRF24L01.c
    ../HARDWARE/COMMON_HARDWARE/RTC/: RTC.C
    ../HARDWARE/COMMON_HARDWARE/DS18B20/: DS18B20.C
  group BSP
    ../HARDWARE/COMMON_HARDWARE/BSP/ADC/: ADC.c
    ../HARDWARE/COMMON_HARDWARE/BSP/delay/: delay.c
    ../HARDWARE/COMMON_HARDWARE/BSP/eeprom/: stc15_eeprom.c
    ../HARDWARE/COMMON_HARDWARE/BSP/EXTI/: stc15_exti.c
    ../HARDWARE/COMMON_HARDWARE/BSP/GPIO/: GPIO.c
    ../HARDWARE/COMMON_HARDWARE/BSP/IIC/: stc15_iic.c
    ../HARDWARE/COMMON_HARDWARE/BSP/PCA/: PCA.c
    ../HARDWARE/COMMON_HARDWARE/BSP/PWM/: stc15_pwm.c
    ../HARDWARE/COMMON_HARDWARE/BSP/SPI/: stc15_spi.c
    ../HARDWARE/COMMON_HARDWARE/BSP/timer/: timer.c
    ../HARDWARE/COMMON_HARDWARE/BSP/USART1/: USART1.C
    ../HARDWARE/COMMON_HARDWARE/BSP/: Readme.txt
  group OS
    ../SOFTWARE/TASK/COMMON_SOFTWARE/RTOS/: Conf_tny.A51
